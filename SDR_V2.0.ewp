# IAR project SDR_V2.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; MEDIA_IntFLASH; USE_USB_OTG_FS; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ; src; src\FFT; src\lcd; src\usb_cdc; Jpeg; inc; Libraries\CMSIS\Include; Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\STM32_USB_Device_Library\Class\cdc\inc; Libraries\STM32_USB_Device_Library\Class\dfu\inc; Libraries\STM32_USB_Device_Library\Class\msc\inc; Libraries\STM32_USB_Device_Library\Core\inc; Libraries\STM32_USB_OTG_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDR_V2.0.hex
  ILINK.IlinkOutputFile: SDR_CS.out
  ILINK.IlinkIcfFile: d:\DOWNLOAS\SDR_V2.0\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: startup_stm32f4xx.s
    src/: system_stm32f4xx.c
  group MAIN_CPU
    src/: main.c
  group MAIN_CPU/ADC
    src/: adc.c
  group MAIN_CPU/BPF_ATT_PRE
    src/: bpf.c
  group MAIN_CPU/Clock
    src/: Clock.c
  group MAIN_CPU/CodecDig
    src/: CS4272dig.c
  group MAIN_CPU/DDC
    src/: ad985x.c dds.c Si5351.c si5351_NT7S.c
  group MAIN_CPU/GPIO
    src/: gpio.c key.c
  group MAIN_CPU/I2C
    src/: i2c.c
  group MAIN_CPU/Lcd
    src/: lcd.c
    src/lcd/: tm_stm32f4_fonts.c tm_stm32f4_gpio.c tm_stm32f4_ili9341.c tm_stm32f4_spi.c
  group MAIN_CPU/Lcd/Jpeg
    Jpeg/: tjpgd.c
  group MAIN_CPU/Menu
    src/: menu_sel.c menu_setup.c
  group MAIN_CPU/Save
    src/: save.c
  group MAIN_CPU/Spi
    src/: Spi.c
  group MAIN_CPU/SWR_Smetr
    src/: Smetr.c
  group MAIN_CPU/SysTime
    src/: SysTime.c
  group MAIN_CPU/USB_CDC
    src/: stm32fxxx_it.c
  group MAIN_CPU/USB_CDC/STM32F4-Discovery
    Utilities/STM32F4-Discovery/: lcd_log.c stm32f4_discovery.c stm32f4_discovery_lcd.c
  group MAIN_CPU/USB_CDC/USB Device/Class/CDC
    Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group MAIN_CPU/USB_CDC/USB Device/Library
    Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group MAIN_CPU/USB_CDC/USB Drivers
    Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group MAIN_CPU/USB_CDC/USB_User
    src/usb_cdc/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group MAIN_CPU/Valcoder
    src/: Valcoder.c
  group SDR
    src/: sdr.c
  group SDR/AGC
    src/: dspAgc.c
  group SDR/Codec_I2S
    src/: CS4272_i2s.c
  group SDR/ECHO
    src/: echo.c
  group SDR/EQ
    src/: equalizer.c
  group SDR/FFT
    src/FFT/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_const_structs.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c
  group SDR/Filters
    src/: anf.c bandpass.c dnr.c nb.c
  group SDR/Filters/LMADF
    src/: lmadf.c
  group SDR/FM_Proc
    src/: fm_demod.c
  group SDR/IQ_imb
    src/: IQBalancer.c Windish.c
  group SDR/PrepareBuf
    src/: PrepareBuf.c
  group SDR/SDR_RX
    src/: rx_sdr.c
  group SDR/SDR_TX
    src/: tx_sdr.c
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
